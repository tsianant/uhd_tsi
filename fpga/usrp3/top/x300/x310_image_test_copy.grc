options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    clean_ip: 'False'
    copyright: 2024 Ettus Research
    description: This is a graphical version of the X310 image core files.
    fpga_dir: /home/mbr0wn/prefix/master/src/uhd/fpga
    generate_options: no_gui
    generator_class_name: RfnocImageGenerator
    generator_module: gnuradio.uhd.grc_workflows
    id: x310_image_core
    ignore_warnings: 'False'
    include_date: 'False'
    include_hash: 'False'
    jobs: '1'
    output_language: rfnoc_bitfile
    reuse: 'False'
    title: Not titled yet
  states: {}

blocks:
- name: samps_per_cycle
  id: variable
  parameters:
    comment: |-
      Samples per cycle is
      fixed on X310. We use
      this to demonstrate the
      basic/simple variable
      expansion capabilities
      of GRC-based RFNoC
      image generation.
    value: '1'
  states: {}
- name: uhd_fpga_00_device_bsp_0
  id: uhd_fpga_device_bsp
  parameters:
    DRAM_WIDTH: '64'
    ENABLE_DRAM: 'True'
    NUM_DRAM_BANKS: '1'
    NUM_DRAM_CHANS: '1'
    RF_BW: '200'
    chdr_width: '64'
    comment: |-
      The choice of "default target" will
      affect which bitfile is generated by
      the image builder if the target value
      is not overridden by the user. This is
      how this example will work for both
      X300 and X310, as well as for HG and
      XG configurations.

      Note that you always need exactly one
      of these BSP blocks for FPGA bitfile
      instantations. The choice of device type
      will autopopulate the inputs and outputs
      to match the underlying device.
    default_target: X310_HG
    device: x310
    type: device
  states: {}
- name: uhd_fpga_01_sep0
  id: uhd_fpga_sep
  parameters:
    alias: eprx0
    buff_size_bytes: '524288'
    comment: |-
      All SEPs have the "Control Traffic"
      setting on "Auto", which is the recommended
      setting. UHD will pick the first SEP (which
      is this one) and assign it a control port.
    ctrl: Auto
  states: {}
- name: uhd_fpga_01_sep0_0
  id: uhd_fpga_sep
  parameters:
    alias: eprx0
    buff_size_bytes: '524288'
    comment: |-
      All SEPs have the "Control Traffic"
      setting on "Auto", which is the recommended
      setting. UHD will pick the first SEP (which
      is this one) and assign it a control port.
    ctrl: Auto
  states: {}
- name: uhd_fpga_02_radio0
  id: uhd_fpga_radio
  parameters:
    NIPC: samps_per_cycle
    NUM_PORTS: '2'
    alias: radio0
    comment: |-
      On X310, we have 2 outputs and 1 input,
      because there is the TwinRX daughterboard,
      but no double-Tx daughterboard.

      Note that the samples-per-cycle value
      must remain at 1, because the X310 has
      no other streaming mode.
    desc: radio.yml
    enable_adv_clk_ctrl: 'False'
  states: {}
- name: uhd_fpga_05_device_none2
  id: uhd_fpga_device_none
  parameters:
    in_out: out
    type: term
  states: {}
- name: uhd_fpga_05_device_none2_0
  id: uhd_fpga_device_none
  parameters:
    in_out: out
    type: term
  states: {}
- name: uhd_fpga_addsub_0
  id: uhd_fpga_addsub
  parameters:
    desc: addsub.yml
    type: block
  states: {}
- name: uhd_fpga_ddc_0
  id: uhd_fpga_ddc
  parameters:
    CIC_MAX_DECIM: '255'
    NUM_HB: '3'
    NUM_PORTS: '1'
  states: {}
- name: uhd_fpga_ddc_0_0
  id: uhd_fpga_ddc
  parameters:
    CIC_MAX_DECIM: '255'
    NUM_HB: '3'
    NUM_PORTS: '1'
  states: {}
- name: uhd_fpga_device_none_0
  id: uhd_fpga_device_none
  parameters:
    in_out: out
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0
  id: uhd_fpga_device_none
  parameters:
    in_out: out
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0_0
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0_1
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0_1_0
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0_2
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0_3
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0_3_0
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_0_3_1
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_0_0_1
  id: uhd_fpga_device_none
  parameters:
    in_out: out
    type: term
  states: {}
- name: uhd_fpga_device_none_0_1
  id: uhd_fpga_device_none
  parameters:
    in_out: out
    type: term
  states: {}
- name: uhd_fpga_device_none_1
  id: uhd_fpga_device_none
  parameters:
    in_out: in
    type: term
  states: {}
- name: uhd_fpga_device_none_1_0
  id: uhd_fpga_device_none
  parameters:
    in_out: out
    type: term
  states: {}
- name: uhd_fpga_radio_0
  id: uhd_fpga_radio
  parameters:
    NIPC: '1'
    NUM_PORTS: '1'
    desc: radio.yml
    enable_adv_clk_ctrl: 'False'
  states: {}
- name: uhd_fpga_sep_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_0_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_0_0_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_0_0_1
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_1
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_2
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_3
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_3_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_3_0_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_3_0_0_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_3_0_0_0_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_3_1
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_4
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_5
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_5_0
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_6
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_sep_7
  id: uhd_fpga_sep
  parameters:
    buff_size_bytes: '32768'
    ctrl: Auto
  states: {}
- name: uhd_fpga_siggen_0
  id: uhd_fpga_siggen
  parameters:
    NUM_PORTS: '1'
    desc: siggen.yml
    type: block
  states: {}
- name: uhd_fpga_siggen_0_0
  id: uhd_fpga_siggen
  parameters:
    NUM_PORTS: '1'
    desc: siggen.yml
    type: block
  states: {}
- name: uhd_fpga_split_stream_0
  id: uhd_fpga_split_stream
  parameters:
    NUM_BRANCHES: '2'
    NUM_PORTS: '1'
    desc: split_stream.yml
    type: block
  states: {}
- name: uhd_fpga_split_stream_0_0
  id: uhd_fpga_split_stream
  parameters:
    NUM_BRANCHES: '2'
    NUM_PORTS: '1'
    desc: split_stream.yml
    type: block
  states: {}
- name: uhd_fpga_switchboard_1
  id: uhd_fpga_switchboard
  parameters:
    NUM_INPUTS: '3'
    NUM_OUTPUTS: '2'
    desc: switchboard.yml
    type: block
  states: {}
- name: uhd_fpga_switchboard_1_0
  id: uhd_fpga_switchboard
  parameters:
    NUM_INPUTS: '4'
    NUM_OUTPUTS: '2'
    desc: switchboard.yml
    type: block
  states: {}

connections:
- [uhd_fpga_00_device_bsp_0, ce_clk, uhd_fpga_addsub_0, ce_clk]
- [uhd_fpga_00_device_bsp_0, ce_clk, uhd_fpga_ddc_0, ce_clk]
- [uhd_fpga_00_device_bsp_0, ce_clk, uhd_fpga_ddc_0_0, ce_clk]
- [uhd_fpga_00_device_bsp_0, ce_clk, uhd_fpga_siggen_0, ce_clk]
- [uhd_fpga_00_device_bsp_0, ce_clk, uhd_fpga_siggen_0_0, ce_clk]
- [uhd_fpga_00_device_bsp_0, ce_clk, uhd_fpga_switchboard_1, ce_clk]
- [uhd_fpga_00_device_bsp_0, ce_clk, uhd_fpga_switchboard_1_0, ce_clk]
- [uhd_fpga_00_device_bsp_0, radio0, uhd_fpga_02_radio0, radio]
- [uhd_fpga_00_device_bsp_0, radio1, uhd_fpga_radio_0, radio]
- [uhd_fpga_00_device_bsp_0, radio_clk, uhd_fpga_02_radio0, radio_clk]
- [uhd_fpga_00_device_bsp_0, radio_clk, uhd_fpga_radio_0, radio_clk]
- [uhd_fpga_00_device_bsp_0, time, uhd_fpga_02_radio0, time]
- [uhd_fpga_00_device_bsp_0, time, uhd_fpga_radio_0, time]
- [uhd_fpga_01_sep0, out0, uhd_fpga_device_none_0_0_0_3_1, term_in]
- [uhd_fpga_01_sep0_0, out0, uhd_fpga_device_none_0_0_0_3_0, term_in]
- [uhd_fpga_02_radio0, ctrlport, uhd_fpga_00_device_bsp_0, ctrlport_radio0]
- [uhd_fpga_02_radio0, out_0, uhd_fpga_01_sep0_0, in0]
- [uhd_fpga_02_radio0, out_1, uhd_fpga_01_sep0, in0]
- [uhd_fpga_05_device_none2, term_out, uhd_fpga_02_radio0, in_1]
- [uhd_fpga_05_device_none2_0, term_out, uhd_fpga_02_radio0, in_0]
- [uhd_fpga_addsub_0, add, uhd_fpga_sep_3, in0]
- [uhd_fpga_addsub_0, sub, uhd_fpga_device_none_0_0_0, term_in]
- [uhd_fpga_ddc_0, out_, uhd_fpga_sep_0, in0]
- [uhd_fpga_ddc_0_0, out_, uhd_fpga_sep_0_0, in0]
- [uhd_fpga_device_none_0, term_out, uhd_fpga_sep_0_0_0, in0]
- [uhd_fpga_device_none_0_0, term_out, uhd_fpga_sep_7, in0]
- [uhd_fpga_device_none_0_0_1, term_out, uhd_fpga_sep_5_0, in0]
- [uhd_fpga_device_none_0_1, term_out, uhd_fpga_sep_3_0_0_0_0, in0]
- [uhd_fpga_device_none_1_0, term_out, uhd_fpga_radio_0, in_]
- [uhd_fpga_radio_0, ctrlport, uhd_fpga_00_device_bsp_0, ctrlport_radio1]
- [uhd_fpga_radio_0, out_, uhd_fpga_device_none_1, term_in]
- [uhd_fpga_sep_0, out0, uhd_fpga_ddc_0, in_]
- [uhd_fpga_sep_0_0, out0, uhd_fpga_ddc_0_0, in_]
- [uhd_fpga_sep_0_0_0, out0, uhd_fpga_switchboard_1_0, in_2]
- [uhd_fpga_sep_0_0_1, out0, uhd_fpga_switchboard_1_0, in_0]
- [uhd_fpga_sep_1, out0, uhd_fpga_device_none_0_0_0_0, term_in]
- [uhd_fpga_sep_2, out0, uhd_fpga_device_none_0_0_0_1, term_in]
- [uhd_fpga_sep_3, out0, uhd_fpga_addsub_0, in_a]
- [uhd_fpga_sep_3_0, out0, uhd_fpga_split_stream_0, in_]
- [uhd_fpga_sep_3_0_0, out0, uhd_fpga_switchboard_1, in_0]
- [uhd_fpga_sep_3_0_0_0, out0, uhd_fpga_switchboard_1, in_1]
- [uhd_fpga_sep_3_0_0_0_0, out0, uhd_fpga_switchboard_1, in_2]
- [uhd_fpga_sep_3_1, out0, uhd_fpga_device_none_0_0_0_3, term_in]
- [uhd_fpga_sep_4, out0, uhd_fpga_split_stream_0_0, in_]
- [uhd_fpga_sep_5, out0, uhd_fpga_device_none_0_0_0_2, term_in]
- [uhd_fpga_sep_5_0, out0, uhd_fpga_addsub_0, in_b]
- [uhd_fpga_sep_6, out0, uhd_fpga_switchboard_1_0, in_1]
- [uhd_fpga_sep_7, out0, uhd_fpga_switchboard_1_0, in_3]
- [uhd_fpga_siggen_0, out_, uhd_fpga_sep_1, in0]
- [uhd_fpga_siggen_0_0, out_, uhd_fpga_sep_2, in0]
- [uhd_fpga_split_stream_0, out_0, uhd_fpga_sep_3_1, in0]
- [uhd_fpga_split_stream_0, out_1, uhd_fpga_sep_3_0, in0]
- [uhd_fpga_split_stream_0_0, out_0, uhd_fpga_sep_4, in0]
- [uhd_fpga_split_stream_0_0, out_1, uhd_fpga_sep_5, in0]
- [uhd_fpga_switchboard_1, out_0, uhd_fpga_sep_3_0_0, in0]
- [uhd_fpga_switchboard_1, out_1, uhd_fpga_sep_3_0_0_0, in0]
- [uhd_fpga_switchboard_1_0, out_0, uhd_fpga_sep_0_0_1, in0]
- [uhd_fpga_switchboard_1_0, out_1, uhd_fpga_sep_6, in0]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-946-ge149d692
